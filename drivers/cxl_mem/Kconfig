## drivers/cxl_mem/Kconfig
```kconfig
config CXL_MEM
tristate "cxl_mem driver"
help
  A driver for cxl type3 device in gem5.
default y
```
